options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bpsk_stage1
    output_language: python
    title: bpsk_stage1
  states: {}

blocks:
- name: freq_centr
  id: variable
  parameters:
    value: '863200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    threshold: '0'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/aude/be-wsn/debug/oskour
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/aude/be-wsn/debug/oskour_head
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aude/be-wsn/debug/envoi
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '32'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_padding: '0'
    length_tag_key: '"frame_len"'
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: (,)
    timing_tag_key: '"rx_time"'
    type: byte
  states: {}
- name: digital_packet_headergenerator_bb_default_0
  id: digital_packet_headergenerator_bb_default
  parameters:
    header_len: '3'
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: '"variable_header_format_default_0"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: header
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_packet_headergenerator_bb_default_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_header_payload_demux_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_file_sink_0_0, '0']
- [digital_packet_headergenerator_bb_default_0, '0', virtual_sink_0_0, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [virtual_source_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_1, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
