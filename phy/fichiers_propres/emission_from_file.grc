options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: em_from_file
    output_language: python
    title: em_from_file
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq_centr
  id: variable
  parameters:
    value: '863200000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, loop_bw, 45)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '32'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: loop_bw
    samples_per_symbol: sps
  states: {}
- name: digital_packet_headergenerator_bb_default_0
  id: digital_packet_headergenerator_bb_default
  parameters:
    header_len: '6'
    len_tag_key: '"packet_len"'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq_centr
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_packet_headergenerator_bb_default_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_packet_headergenerator_bb_default_0, '0', blocks_tagged_stream_mux_0, '1']
- [fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '1']
- [fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
